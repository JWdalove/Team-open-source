# Keil uVision project Sentry.uvprojx, settings and files
target RM_2019_Sentry (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F405ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,MOTION_DRIVER_TARGET_MSP430,MPU9250,__FPU_PRESENT=1,ARM_MATH_CM4,__CC_ARM
  c misc: --C99
  c include: ..\CORE;..\FWLIB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\CORE\Include;..\DRIVER;..\DRIVER\system;..\DRIVER\Configuration;..\JUDGE;..\CORE\CMSIS_RTOS
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group README
    ../README/: README.txt
  group Task
    ../DRIVER/: Start_task.c Task_CANSend.c Chassis_Task.c Gimbal_Task.c Chassis_Monitor.c Gimbal_Monitor.c Task_Communication.c
  group USER
    ../DRIVER/: main.c struct.c struct.h constant.h stm32f4xx_it.c system_stm32f4xx.c Status_Update.c Cloud_Control.c Poked_Control.c Chassis_Control.c
    ../DRIVER/Configuration/: ramp.c PWM.c GPIO.c CAN_1.c CAN_2.c LQoled.c uart_DBUS.c uart_MiniPC.c uart_mpu9250.c UART_Judge.c Kalman_Filter.c kalman.c matrix.c
    ../DRIVER/system/: delay.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
    ../CORE/CMSIS_RTOS/: cmsis_os.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_tim.c stm32f4xx_dma.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c tasks.c timers.c queue.c heap_2.c port.c
  group JUDGE
    ../JUDGE/: comm_task.c communicate.c data_fifo.c info_interactive.c judgement_info.c protocol.c
  group DSP
    ../CORE/DSP_Lib/Source/MatrixFunctions/: arm_mat_add_f32.c arm_mat_add_q15.c arm_mat_add_q31.c arm_mat_cmplx_mult_f32.c arm_mat_cmplx_mult_q15.c arm_mat_cmplx_mult_q31.c arm_mat_init_f32.c arm_mat_init_q15.c arm_mat_init_q31.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_mult_f32.c arm_mat_mult_fast_q15.c arm_mat_mult_fast_q31.c arm_mat_mult_q15.c arm_mat_mult_q31.c arm_mat_scale_f32.c arm_mat_scale_q15.c arm_mat_scale_q31.c arm_mat_sub_f32.c arm_mat_sub_q15.c arm_mat_sub_q31.c arm_mat_trans_f32.c arm_mat_trans_q15.c arm_mat_trans_q31.c
software components: CMSIS:CORE 5.1.1, CMSIS:DSP 1.5.2
